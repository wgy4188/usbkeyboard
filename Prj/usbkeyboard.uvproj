# Keil uVision project usbkeyboard.uvproj, settings and files
target flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbkeyboard +hex
  c flags: Optim=1
  c include: ..\USB\include;..\FWLIB\include;..\cmsis;..\Bsp;..\App
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group cmsis
    ./: startup_LPC17xx.s
    ../cmsis/: system_LPC17xx.c
  group fwlib
    ../FWLIB/source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group usb
    ../USB/source/: hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group app
    ../App/: main.c dispose.c information.c key.c led.c upgrade.c
  group bsp
    ../Bsp/: gpio.c pwm.c timer.c uart.c spi.c adc.c iic.c hidio.c
